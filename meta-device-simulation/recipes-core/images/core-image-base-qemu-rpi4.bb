require recipes-core/images/core-image-base.bb

SUMMARY = "QEMU raspi4b용 core-image-base"

WKS_FILE = "sdimage-raspberrypi-qemu.wks"
IMAGE_FSTYPES = "wic wic.bz2"
